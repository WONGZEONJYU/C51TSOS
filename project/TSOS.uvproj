# Keil uVision project TSOS.uvproj, settings and files
target TSOS (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TSOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ossrc;..\main;..\Peripherals;..\app
  group ossrc
    ./: STARTUP.A51
    ../ossrc/: cpu.c task.c
  group main
    ../main/: main.c
  group Peripherals
    ../Peripherals/: uart1.c
